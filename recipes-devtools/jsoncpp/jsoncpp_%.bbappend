BBCLASSEXTEND += "nativesdk"

EXTRA_OECMAKE += "-DJSONCPP_WITH_CMAKE_PACKAGE=ON"
